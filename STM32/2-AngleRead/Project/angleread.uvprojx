# Keil uVision project angleread.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: angleread +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\Lib\FWLIB\inc;..\Simple_FOC;..\User;..\Main
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ../Lib/CMSIS/StartUp/: startup_stm32f10x_md.s
  group FWLIB
    ../Lib/FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Lib/CMSIS/: core_cm3.c system_stm32f10x.c
  group USER
    ../User/: delay.c timer.c usart.c
  group SimpleFOC
    ../Simple_FOC/: foc.c utils.c hall.c
  group Main
    ../Main/: main.c stm32f10x_it.c
software components: CMSIS:CORE 5.6.0
